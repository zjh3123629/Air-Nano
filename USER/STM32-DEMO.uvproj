# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32-DEMO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\Driver\LED;..\Driver\IIC;..\Driver\MPU6050;..\Driver\IMU;..\Driver\CONTROL;..\Driver\Delay;..\Driver\TIM;..\Driver\SPI;..\Driver\NRF24L01;..\Driver\APP;..\Driver\UART;..\Driver\MOTOR;..\Driver\RC;..\Driver\ADC;..\Driver\PARAM;..\Driver\EEPROM;..\Driver\MS5611
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYS
    ./: main.c stm32f10x_it.c
  group Driver
    ../Driver/LED/: led.c
    ../Driver/SPI/: Spi.c
    ../Driver/ADC/: adc.c
    ../Driver/IIC/: I2C.c
    ../Driver/TIM/: time.c
    ../Driver/MOTOR/: moto.c
    ../Driver/UART/: usart.c
    ../Driver/Delay/: delay.c
    ../Driver/EEPROM/: eeprom.c
    ../Driver/MPU6050/: mpu6050.c
    ../Driver/NRF24L01/: NRF24L01.c
    ../Driver/MS5611/: MS5611.c
  group APP
    ../Driver/RC/: RC.c
    ../Driver/IMU/: IMU.c
    ../Driver/APP/: app.c
    ../Driver/PARAM/: Param.c
    ../Driver/CONTROL/: CONTROL.c
